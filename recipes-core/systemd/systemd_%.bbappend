PACKAGECONFIG_remove = "timesyncd networkd resolved"
